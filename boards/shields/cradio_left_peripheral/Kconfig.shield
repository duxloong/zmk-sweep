## boards/shields/cradio_left_peripheral/Kconfig.shield
```kconfig
config SHIELD_CRADIO_LEFT_PERIPHERAL
    def_bool $(shields_list_contains,cradio_left_peripheral)
```
